File: Boards/interfaceBoard/interfaceBoard/12v-4vVoltage_Divider.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: WIP
Parts:
- renumbered R17 to R4, R18 to R5
